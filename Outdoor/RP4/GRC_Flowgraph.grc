options:
  parameters:
    generate_options: no_gui
    id: default
    output_language: python
    realtime_scheduling: '1'
    title: TX USRP QPSK symbols
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gmelk/Documents/WaveForm.bin
    length: '1278'
    repeat: 'True'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom scipy.io import loadmat\nimport threading\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - load symbols from a .mat file and transmit\"\"\"\n\n    def __init__(self, file_path='/home/gmelk/Documents/WaveForm.mat'):  # default file path\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n        self.file_path = file_path\n        self.symbols = self.load_symbols()\n        self.symbol_index = 0\n        self.lock = threading.Lock()\n\n    def load_symbols(self):\n        \"\"\"Load symbols from a .mat file\"\"\"\n        try:\n            mat_data = loadmat(self.file_path)\n            symbols = mat_data['TxSymb'].flatten()\n            return np.array(symbols, dtype=np.complex64)\n        except Exception as e:\n            print(f\"Error loading symbols: {e}\")\n            return np.array([], dtype=np.complex64)\n\n    def work(self, input_items, output_items):\n        \"\"\"Transmit loaded symbols\"\"\"\n        num_output_items = len(output_items[0])\n        num_symbols = len(self.symbols)\n\n        if num_symbols == 0:\n            return 0\n\n        with self.lock:\n            for i in range(num_output_items):\n                output_items[0][i] = self.symbols[self.symbol_index]\n                self.symbol_index = (self.symbol_index + 1) % num_symbols\n\n        return num_output_items\n\n"
    file_path: '''/home/gmelk/Documents/WaveForm.mat'''
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 1.3e9
    dev_addr: serial=30998D7
    gain0: '80'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
